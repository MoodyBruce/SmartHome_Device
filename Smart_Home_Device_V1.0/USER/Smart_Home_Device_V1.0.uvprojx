# Keil uVision project Smart_Home_Device_V1.0.uvprojx, settings and files
target Smart_Home_Device_V1.0 (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Smart_Home_Device_V1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c misc: --diag_suppress=188;--diag_suppress=1
  c include: ..\USER;..\Tuya\mcu_sdk;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HALLIB\STM32F0xx_HAL_Driver\Inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\RI;..\HARDWARE\SHT30;..\HARDWARE\UART;..\HARDWARE\TIMER;..\HARDWARE\I2C;..\HARDWARE\ADC;..\HARDWARE\WKUP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c system_stm32f0xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0.h startup_stm32f030x8.s
  group HALLIB
    ../HALLIB/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED/: oled.c text.c
    ../HARDWARE/SHT30/: sht30.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/RI/: ri.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/WKUP/: wkup.c
  group TUYA
    ../Tuya/mcu_sdk/: mcu_api.c protocol.c system.c
